# Keil uVision project template.uvprojx, settings and files
target STM32F103C (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  AfterMake: fromelf.exe #L --vhx --8x1 --output main.hex;fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\lib\inc;..\startup;..\user;..\driver\iic;..\driver\spi;..\driver\uart;..\misc;..\driver\delay;..\driver\usb\usb_driver\inc;..\driver\usb\usb_lib\inc;..\misc;..\device\usb
  memory RVCT4: ROM 0x8003000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../user/: main.c
  group Devices
    ../device/usb/: usb_manager.c
  group Startup
    ../startup/: core_cm3.c startup_stm32f10x_md.s system_stm32f10x.c
    ../user/: stm32f10x_it.c
  group System
    ../lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Driver
    ../driver/iic/: i2c.c
    ../driver/spi/: spi.c
    ../driver/uart/: uart.c
    ../driver/delay/: delay.c
  group Usb_lib
    ../driver/usb/usb_lib/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Usb_driver
    ../driver/usb/usb_driver/src/: hw_config.c usb_desc.c usb_istr.c usb_prop.c usb_pwr.c usb_endp.c
  group Misc
    ../misc/: sys.c unicode.c
  group Test
    ../test/: testMain.c
